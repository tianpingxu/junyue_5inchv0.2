# Keil uVision project CCM4211_DISP.uvprojx, settings and files
target DEBUG_QSPI (6160000::V6.16::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: CCM4211_DISP +hex
  AfterMake: fromelf --bin --output ..\obj\bin\CCM4211_DISP.bin ..\obj\obj_debug_qspi\CCM4211_DISP.axf
  AfterMake: fromelf --text -a -c --output ..\obj\asm\CCM4211_DISP.asm ..\obj\obj_debug_qspi\CCM4211_DISP.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEMO,LVGL_MCU
  c misc: -Wno-invalid-source-encoding
  c include: ..\Src\src;..\Src\inc;..\Src\core;..\Src\core\inc;..\Src\src\sys\inc;..\Src\src\drv\inc;..\Src\src\drv\lib\inc;..\Src\src\bsp;..\Src\src\demo\i2s;..\Src\src\demo\inc;..\Src\src\demo\display;..\Src\src\demo\display\driveric;..\Src\src\demo\touch;..\Src\src\demo\touch\driveric;..\Src\components\usbd;..\Src\components\usbd\hid;..\Src\components\usbd\ms;..\Src\components\usbd\cdc;..\Src\components\usbh;..\Src\components\dac_audio;..\Src\components\freertos\include;..\Src\components\freertos\portable\GCC\ARM_CM4F;..\Src\components\freertos\test;..\Src\components\freertos;..\Src\components\lwip\src;..\Src\components\lwip\eth;..\Src\components\lwip\arch;..\Src\components\lwip\src\include;..\Src\components\lwip\src\include\lwip;..\Src\components\lwip;..\Src\components\lvgl;..\Src\components\lvgl\src;..\Src\components\lvgl\porting;..\Src\components\lvgl\src\porting;..\Src\components\lvgl\src\font;..\Src\components\lvgl\demos;..\Src\components\lvgl\demos\widgets;..\Src\components\lvgl\test;..\Src\components\jpeg_accelerator;..\Src\components\eth;..\Src\components\fatfs;..\Src\components\lvgl\generated;..\Src\components\iap;..\Src\components\cherryusb;..\Src\components\cherryusb\class\hub;..\Src\components\cherryusb\class\video;..\Src\components\cherryusb\common;..\Src\components\cherryusb\core;..\Src\components\cherryusb\port\musb;..\Src\components\cherryusb\demo\usbh_uvc;..\Src\components\lvgl\ui_eez;..\Src\components\lvgl\ui_eez\custom
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ccm4211.sct
  group main
    ../Src/src/: main.c
  group ccore
    ../Src/core/: system_NVIC.c startup_ARMCM7.s system_ARMCM7.c ccm4211_hal_cortex.c
  group sys
    ../Src/src/sys/: common.c debug.c delay.c interrupt.c sys.c bootconfig.c
  group lib
    ../Src/src/drv/lib/: libpsram.lib libaxiflow.lib libalgo.lib
  group drv
    ../Src/src/drv/: wdt_drv.c tc_drv.c adc_drv.c cpm_drv.c dma_drv.c eport_drv.c ioctrl_drv.c pit32_drv.c reset_drv.c ssi_drv.c trng_drv.c usb_drv.c spi_drv.c uart_drv.c systick_drv.c i2c_drv.c pwmt_drv.c can_drv.c i2s_drv.c dac_drv.c rtc_drv.c pinswap_drv.c axidma_drv.c i8080_drv.c lcdc_drv.c sdio_drv.c image_decoder_drv.c dma2d_drv.c crc_drv.c algo_drv.c ssislv_drv.c ssi_sram.c
    ../Src/src/bsp/: audio_adpcm.c
  group bsp
    ../Src/src/bsp/: adc_hal.c can_hal.c eport_hal.c i2c_hal.c pwmt_hal.c spi_hal.c ssi_hal.c uart_hal.c dac_hal.c audio_hal.c rtc_hal.c i2s_hal.c tc_hal.c wdt_hal.c dma_hal.c pit32_hal.c ioctrl_hal.c axidma_hal.c i8080_hal.c reset_hal.c trng_hal.c lcdc_hal.c cpm_hal.c sdio_hal.c image_decoder_hal.c dma2d_hal.c crc_hal.c algo_hal.c ssislv_hal.c
  group demo/uart
    ../Src/src/demo/uart/: uart_test.c
  group demo/can
    ../Src/src/demo/can/: can_test.c
  group demo/pmwt
    ../Src/src/demo/pwmt/: pwmt_test.c
  group demo/pit
    ../Src/src/demo/pit/: pit32_test.c
  group demo/tc
    ../Src/src/demo/tc/: tc_test.c
  group demo/wdt
    ../Src/src/demo/wdt/: wdt_test.c
  group demo/eport
    ../Src/src/demo/eport/: eport_test.c
  group demo/spi
    ../Src/src/demo/spi/: spi_test.c
  group demo/adc
    ../Src/src/demo/adc/: adc_test.c
  group demo/dac
    ../Src/src/demo/dac/: dac_test.c
  group demo/rtc
    ../Src/src/demo/rtc/: rtc_test.c
  group demo/i2c
    ../Src/src/demo/i2c/: i2c_test.c
  group demo/i2s
    ../Src/src/demo/i2s/: i2s_test.c wm8978.c
  group demo/algo
    ../Src/src/demo/algo/: algo_test.c
  group demo/reset
    ../Src/src/demo/reset/: reset_test.c
  group demo/lowpower
    ../Src/src/demo/lowpower/: lowpower_test.c
  group demo/ssinor
    ../Src/src/demo/ssi/: ssi_test.c
  group demo/display
    ../Src/src/demo/display/: lcd_interface.c
    ../Src/src/demo/display/driveric/: rgb_lcd.c
  group demo/touch
    ../Src/src/demo/touch/: tp_interface.c tp_test.c
    ../Src/src/demo/touch/driveric/: gt911.c touch_adc.c ts_calibrate.c tslib.c st77102.c
  group demo/imgdec
    ../Src/src/demo/imgdec/: image_decoder_data.c image_decoder_test.c
  group demo/axidma
    ../Src/src/demo/axidma/: axidma_test.c
  group demo/i8080
    ../Src/src/demo/i8080/: i8080_test.c
  group demo/lcdc
    ../Src/src/demo/lcdc/: lcdc_test.c
  group demo/dma2d
    ../Src/src/demo/dma2d/: dma2d_test.c
  group demo/lcdc_dma2d
    ../Src/src/demo/lcdc_dma2d/: lcdc_dma2d_test.c
  group demo/sdio_sd
    ../Src/src/demo/sdio/: sdio_test.c
  group demo/nandflash
    ../Src/src/demo/nand flash/: nandflash_test.c nandflash_interface.c
  group components/fatfs
    ../Src/components/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c dictionary.c iniparser.c
  group components/eth
    ../Src/components/eth/: eth_hal.c eth_test.c iperf_client.c
  group components/lwip
    ../Src/components/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Src/components/lwip/src/apps/lwiperf/: lwiperf.c
    ../Src/components/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c sys1.c
    ../Src/components/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Src/components/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Src/components/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Src/components/lwip/arch/: sys_arch.c ethernetif.c
    ../Src/components/lwip/eth/: bsp_eth.c
  group components/freertos
    ../Src/components/freertos/: event_groups.c list.c queue.c tasks.c timers.c
    ../Src/components/freertos/test/: freertos_test.c
    ../Src/components/freertos/portable/MemMang/: heap_4.c
    ../Src/components/freertos/portable/GCC/ARM_CM4F/: port.c
  group components/dac_audio
    ../Src/components/dac_audio/: audio_service.c audio_test.c
  group components/lvgl/src
    ../Src/components/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Src/components/lvgl/src/display/: lv_display.c
    ../Src/components/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../Src/components/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c lv_draw_sw_gradient.c
    ../Src/components/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Src/components/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Src/components/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
    ../Src/components/lvgl/src/layouts/flex/: lv_flex.c
    ../Src/components/lvgl/src/layouts/grid/: lv_grid.c
    ../Src/components/lvgl/src/layouts/: lv_layout.c
    ../Src/components/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Src/components/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Src/components/lvgl/src/libs/bmp/: lv_bmp.c
    ../Src/components/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Src/components/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Src/components/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Src/components/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../Src/components/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Src/components/lvgl/src/libs/libpng/: lv_libpng.c
    ../Src/components/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Src/components/lvgl/src/libs/lz4/: lz4.c
    ../Src/components/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Src/components/lvgl/src/libs/rle/: lv_rle.c
    ../Src/components/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Src/components/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Src/components/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Src/components/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ../Src/components/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ../Src/components/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c
    ../Src/components/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Src/components/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Src/components/lvgl/src/others/gridnav/: lv_gridnav.c
    ../Src/components/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Src/components/lvgl/src/others/imgfont/: lv_imgfont.c
    ../Src/components/lvgl/src/others/monkey/: lv_monkey.c
    ../Src/components/lvgl/src/others/observer/: lv_observer.c
    ../Src/components/lvgl/src/others/snapshot/: lv_snapshot.c
    ../Src/components/lvgl/src/others/sysmon/: lv_sysmon.c
    ../Src/components/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../Src/components/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Src/components/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Src/components/lvgl/src/stdlib/: lv_mem.c
    ../Src/components/lvgl/src/themes/default/: lv_theme_default.c
    ../Src/components/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Src/components/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Src/components/lvgl/src/themes/: lv_theme.c
    ../Src/components/lvgl/src/tick/: lv_tick.c
    ../Src/components/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Src/components/lvgl/src/widgets/arc/: lv_arc.c
    ../Src/components/lvgl/src/widgets/bar/: lv_bar.c
    ../Src/components/lvgl/src/widgets/button/: lv_button.c
    ../Src/components/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Src/components/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Src/components/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Src/components/lvgl/src/widgets/chart/: lv_chart.c
    ../Src/components/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Src/components/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Src/components/lvgl/src/widgets/image/: lv_image.c
    ../Src/components/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Src/components/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Src/components/lvgl/src/widgets/label/: lv_label.c
    ../Src/components/lvgl/src/widgets/led/: lv_led.c
    ../Src/components/lvgl/src/widgets/line/: lv_line.c
    ../Src/components/lvgl/src/widgets/list/: lv_list.c
    ../Src/components/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Src/components/lvgl/src/widgets/menu/: lv_menu.c
    ../Src/components/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Src/components/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Src/components/lvgl/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Src/components/lvgl/src/widgets/roller/: lv_roller.c
    ../Src/components/lvgl/src/widgets/scale/: lv_scale.c
    ../Src/components/lvgl/src/widgets/slider/: lv_slider.c
    ../Src/components/lvgl/src/widgets/span/: lv_span.c
    ../Src/components/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Src/components/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Src/components/lvgl/src/widgets/switch/: lv_switch.c
    ../Src/components/lvgl/src/widgets/table/: lv_table.c
    ../Src/components/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Src/components/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Src/components/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Src/components/lvgl/src/widgets/win/: lv_win.c
    ../Src/components/lvgl/src/: lv_init.c
    ../Src/components/lvgl/src/libs/ccoredec/: lv_ccore_decoder.c
  group components/lvgl/porting
    ../Src/components/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group components/lvgl/demo
    ../Src/components/lvgl/demos/widgets/: lv_demo_widgets.c
    ../Src/components/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    ../Src/components/lvgl/test/: lvgl_test.c
  group components/jpeg_accelerator
    ../Src/components/jpeg_accelerator/: jpeg_accele_data.c jpeg_accelerator_test.c
  group components/usbhost
    ../Src/components/usbh/: usb_host_config.c usb_host_control.c usb_host_isr.c usb_host_scsi.c usb_host_setup.c usb_host_test.c
  group components/usbdevice
    ../Src/components/usbd/cdc/: usb_cdc_config.c usb_cdc_hardware.c usb_cdc_protocol.c
    ../Src/components/usbd/hid/: usb_hid_config.c usb_hid_hardware.c usb_hid_protocol.c
    ../Src/components/usbd/ms/: usb_ms_config.c usb_ms_hardware.c usb_ms_protocol.c
    ../Src/components/usbd/: usb_device_test.c usb_protocol.c
  group components/iap
    ../Src/components/iap/: iap_test.c iap_ex_flash.c lcd_iap.c
  group components/cherryusb
    ../Src/components/cherryusb/class/hub/: usbh_hub.c
    ../Src/components/cherryusb/class/video/: usbh_video.c
    ../Src/components/cherryusb/core/: usbh_core.c
    ../Src/components/cherryusb/demo/usbh_uvc/: usb_uvc_lcd.c usbh_uvc_process.c usbh_uvc_test.c
    ../Src/components/cherryusb/port/musb/: usb_hc_musb.c usb_glue_ccore.c
    ../Src/components/cherryusb/osal/: usb_osal_freertos.c
  group ui_eez
    ../Src/components/lvgl/ui_eez/: images.c screens.c styles.c ui.c
  group ui_fonts
    ../Src/components/lvgl/ui_eez/fonts/: ui_font_cal_sans_semi_bold_40.c ui_font_harmony_os_sans_kr_regular_font_28.c ui_font_harmony_os_sans_sc_regular_font_20.c ui_font_harmony_os_sans_sc_regular_font_24.c ui_font_harmony_os_sans_sc_regular_font_28.c ui_font_harmony_os_sans_sc_regular_font_32.c ui_font_harmony_os_sans_sc_regular_font_36.c ui_font_harmony_os_sans_sc_regular_font_48.c ui_font_harmony_os_sans_sc_regular_font_64.c ui_font_harmony_os_sans_sc_regular_font_72.c ui_font_harmony_os_sans_sc_regular_font_112.c ui_font_harmony_os_sans_sc_regular_font_128.c ui_font_harmony_os_sans_sc_regular_font_96.c ui_font_harmony_os_sans_kr_regular_font_24.c ui_font_harmony_os_sans_kr_regular_font_32.c ui_font_harmony_os_sans_kr_regular_font_36.c ui_font_harmony_os_sans_sc_regular_font_28_backup.c
  group ui_image
    ../Src/components/lvgl/ui_eez/image/: ui_image_ceiling_lum_max.c ui_image_side_lum_max.c ui_image_fan_speed_show_01.c ui_image_fan_speed_show_02.c ui_image_fan_speed_show_03.c ui_image_fan_speed_show_04.c ui_image_fan_speed_show_05.c ui_image_fan_speed_show_06.c ui_image_fan_speed_show_07.c ui_image_fan_speed_show_08.c ui_image_fan_speed_show_09.c ui_image_fan_speed_show_10.c
  group ui_custom
    ../Src/components/lvgl/ui_eez/custom/: crc16.c custom.c my_actions.c protocol.c
target DEBUG_SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: ccm4201s_fw
  AfterMake: fromelf --bin --output ..\obj\bin\CCM4201S_FW.bin ..\obj\obj_debug_qspi\ccm4201s_fw.axf
  AfterMake: fromelf --text -a -c --output ..\obj\asm\CCM4201S_FW.asm ..\obj\obj_debug_qspi\ccm4201s_fw.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: DEMO,ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING,__CC_ARM,__FPU_PRESENT
  c misc: --gnu
  c include: ..\Src\inc;..\Src\core\inc;..\Src\src\sys\inc;..\Src\src\drv\inc;..\Src\src\hal\inc;..\Src\src\app;..\Src\src\app\usb;..\Src\src\app\usb\ms;..\Src\src\app\usb\hid;..\Src\src\app\usb\cdc;..\Src\src\app\usb\ccid;..\Src\src\app\smartcard;..\Src\src\app\reader;..\Src\src\demo;..\Src\src\app\lcd;..\Src\src\app\audio
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target DEBUG_QSPI_MID (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: ccm4201s_fw
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING,__CC_ARM,__FPU_PRESENT
  c misc: --gnu
  c include: ..\Src\inc;..\Src\core\inc;..\Src\src\sys\inc;..\Src\src\drv\inc;..\Src\src\hal\inc;..\Src\src\app;..\Src\src\app\usb;..\Src\src\app\usb\ms;..\Src\src\app\usb\hid;..\Src\src\app\usb\cdc;..\Src\src\app\usb\ccid;..\Src\src\app\smartcard;..\Src\src\app\reader;..\Src\src\demo
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target DEBUG_QSPI_MIN (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: ccm4201s_fw
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: as above
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
